# Raspberry Pi platform-specific RAUC configuration
# Provides system.conf for each supported Raspberry Pi machine

FILESEXTRAPATHS:prepend := "${THISDIR}/files/${MACHINE}:"
