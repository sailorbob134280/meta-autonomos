FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://k3s-netfilter.cfg"
