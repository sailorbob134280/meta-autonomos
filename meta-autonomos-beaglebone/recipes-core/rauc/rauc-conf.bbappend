# BeagleBone platform-specific RAUC configuration
# Provides system.conf for BeagleBone machines

FILESEXTRAPATHS:prepend := "${THISDIR}/files/${MACHINE}:"
