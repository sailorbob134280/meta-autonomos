require recipes-images/base/autonomos-common.inc
